<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gnuradio_rftap_encapsulation</value></param>
<param><key>author</key><value>alexandra HULOT</value></param>
<param><key>description</key><value>RFTAP encapsulation for wifi packets from file source</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rssi</value></param>
<param><key>config_file</key><value>/home/alexandra/rftap_param.config</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>rssi</value></param>
<param><key>section</key><value>headers</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>snr</value></param>
<param><key>config_file</key><value>/home/alexandra/rftap_param.config</value></param>
<param><key>value</key><value>10</value></param>
<param><key>option</key><value>snr</value></param>
<param><key>section</key><value>headers</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>test_pdu.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/alexandra/winhome/Downloads/out.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_pdu_set</key>
<param><key>id</key><value>blocks_pdu_set_0</value></param>
<param><key>k</key><value>pmt.to_pmt("power")</value></param>
<param><key>v</key><value>pmt.to_pmt(rssi)</value></param>
</block>
<block>
<key>blocks_pdu_set</key>
<param><key>id</key><value>blocks_pdu_set_1</value></param>
<param><key>k</key><value>pmt.to_pmt("snr")</value></param>
<param><key>v</key><value>pmt.to_pmt(snr)</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>9999</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
<param><key>packet_len</key><value>92</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>tech</key><value>127</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_size</value></param>
<param><key>label</key><value>frame_size</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>rftap_rftap_encap</key>
<param><key>id</key><value>rftap_rftap_encap_0</value></param>
<param><key>custom_dlt</key><value>105</value></param>
<param><key>custom_dissector_name</key><value></value></param>
<param><key>encapsulation_from</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_set_0</source_block_id><sink_block_id>blocks_pdu_set_1</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_pdu_set_1</source_block_id><sink_block_id>rftap_rftap_encap_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_pdu_set_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rftap_rftap_encap_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>rftap_rftap_encap_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
